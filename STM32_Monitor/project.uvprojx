# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,APP_VECTOR_BASE_ADDR=0x08000000
  c include: .\Start;.\Include;.\Library;.\System;.\User;.\Drivers;.\BSP;.\Middlewares;.\App;..\Bootloader_OTA\Shared\Inc;.\Middlewares\FreeRTOS\Source;.\Middlewares\FreeRTOS\Source\portable\MemMang;.\Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM3;.\Middlewares\FreeRTOS\Source\include;.\Middlewares\FreeRTOS\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group BSP
    ./BSP/: bsp_adc.c bsp_adc.h bsp_gpio.c bsp_gpio.h bsp_i2c.c bsp_i2c.h bsp_iwdg.c bsp_iwdg.h bsp_pwm.c bsp_pwm.h bsp_timer.c bsp_timer.h bsp_usart.c bsp_usart.h
  group Drivers
    ./Drivers/: amg8833.c amg8833.h atk_esp01.c atk_esp01.h dht11.c dht11.h encoder.c encoder.h hcsr04.c hcsr04.h light_sensor.c light_sensor.h oled.c oled.h servo.c servo.h
  group Middlewares
    ./Middlewares/: at_parser.c at_parser.h error_code.h ring_buffer.c ring_buffer.h system_data.h
  group Include
    ./Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group FreeRTOS_Source
    ./Middlewares/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ./Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group FreeRTOS_MemMang
    ./Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Config
    ./Middlewares/FreeRTOS/Config/: FreeRTOSConfig.h
  group App
    ./App/: app_detect.c app_detect.h app_display.c app_display.h app_input.c app_input.h app_log.c app_log.h app_main.c app_main.h app_menu.c app_menu.h app_protocol.c app_protocol.h app_sensor.c app_sensor.h app_scan.c app_scan.h app_servo_control.c app_servo_control.h app_system.c app_system.h app_task.c app_task.h app_ota_confirm.c app_ota_confirm.h app_upload.c app_upload.h app_upload_config.h app_ota_config.h app_ota_download.c app_ota_download.h
  group BootloaderShared
    ../Bootloader_OTA/Shared/Src/: crc32.c upgrade_config_if.c flash_if.c firmware_verify.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
target Monitor Slot A (6140001::V6.14.1::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: monitor_slot_a
  AfterMake: D:\Develop\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe --bin --output .\Objects\SlotA\monitor_slot_a.bin .\Objects\SlotA\monitor_slot_a.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,APP_VECTOR_BASE_ADDR=0x08008000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
target Monitor Slot B (6140001::V6.14.1::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: monitor_slot_b
  AfterMake: D:\Develop\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe --bin --output .\Objects\SlotB\monitor_slot_b.bin .\Objects\SlotB\monitor_slot_b.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,APP_VECTOR_BASE_ADDR=0x08038000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8038000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
