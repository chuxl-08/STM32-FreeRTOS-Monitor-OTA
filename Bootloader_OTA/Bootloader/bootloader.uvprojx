# Keil uVision project bootloader.uvprojx, settings and files
target Bootloader (6140001::V6.14.1::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Shared\Config;.\Inc;.\Src;..\Shared\Inc;..\Shared\Src;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Inc
    ./Inc/: boot_jump.h serial_iap.h
  group Src
    ./Src/: main.c boot_jump.c serial_iap.c
  group Shared\Inc
    ../Shared/Inc/: crc32.h firmware.h firmware_verify.h flash_if.h memory_map.h upgrade_config.h platform.h upgrade_config_if.h
  group Shared\Src
    ../Shared/Src/: crc32.c platform.c firmware_verify.c flash_if.c upgrade_config_if.c
  group Shared\Config
    ../Shared/Config/: stm32f10x_conf.h
  group Libraries\CMSIS
    ../Libraries/CMSIS/: core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries\STM32F10x_StdPeriph_Driver\inc
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries\STM32F10x_StdPeriph_Driver\src
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
